# IAR project S32K144.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: CPU_S32K148; BRS_DERIVATIVE_S32K144; BASIC_RUNTIME_SYSTEM_TYPE_MSR4; DISABLE_WDOG
  ICCARM.CCIncludePath2: IAR_Project\BSW\_Common; IAR_Project\BSW\BswM; IAR_Project\BSW\Can; IAR_Project\BSW\CanIf; IAR_Project\BSW\CanSM; IAR_Project\BSW\CanTp; IAR_Project\BSW\CanTrcv_30_Tja1043; IAR_Project\BSW\Com; IAR_Project\BSW\ComM; IAR_Project\BSW\Crc; IAR_Project\BSW\Dcm; IAR_Project\BSW\Dem; IAR_Project\BSW\Det; IAR_Project\BSW\Ea; IAR_Project\BSW\EcuM; IAR_Project\BSW\Eep_30_XXi2c01; IAR_Project\BSW\IoHwAb; IAR_Project\BSW\Mcal_S32k; IAR_Project\BSW\MemIf; IAR_Project\BSW\Nm; IAR_Project\BSW\NmOsek; IAR_Project\BSW\NvM; IAR_Project\BSW\Os; IAR_Project\BSW\PduR; IAR_Project\BSW\RamTst; IAR_Project\BSW\vDem42; IAR_Project\BSW\VStdLib; IAR_Project\BSW\WdgIf; IAR_Project\BSW\WdgM; IAR_Project\MCAL\Adc_TS_T40D2M10I1R0\include; IAR_Project\MCAL\Base_TS_T40D2M10I1R0\include; IAR_Project\MCAL\Dio_TS_T40D2M10I1R0\include; IAR_Project\MCAL\Fls_TS_T40D2M10I1R0\include; IAR_Project\MCAL\Gpt_TS_T40D2M10I1R0\include; IAR_Project\MCAL\Icu_TS_T40D2M10I1R0\include; IAR_Project\MCAL\Mcu_TS_T40D2M10I1R0\include; IAR_Project\MCAL\Ocu_TS_T40D2M10I1R0\include; IAR_Project\MCAL\Port_TS_T40D2M10I1R0\include; IAR_Project\MCAL\Spi_TS_T40D2M10I1R0\include; IAR_Project\MCAL\Wdg_TS_T40D2M10I1R0\include; DAV_Project\Appl\GenData; DAV_Project\Appl\GenData\include; DAV_Project\Appl\GenData\Components; Appl\Include; Appl\shared\zBrs_AsrEmbeddedRunTimeSystemCfg5; Appl\shared\zBrs_ArmCommon; Appl\shared\zBrs_S32Arm; IAR_Project\Src\Device; DAV_Project\Appl\Source; IAR_Project\Src\BSW\_Common; IAR_Project\Include; IAR_Project\Src\MCAL\Port_TS_T40D2M10I1R0\include; IAR_Project\Src\BSW\Os; IAR_Project\Src\MCAL\Base_TS_T40D2M10I1R0\include; IAR_Project\Src\BSW\Mcal_S32k; IAR_Project\Src\BSW\Det; IAR_Project\Src\BSW\VStdLib; IAR_Project\Src\MCAL\Mcu_TS_T40D2M10I1R0\include; IAR_Project\Src\BSW\BswM; IAR_Project\Src\BSW\EcuM; IAR_Project\Src\MCAL\Dio_TS_T40D2M10I1R0\include; DAV_Project\Appl\shared; DAV_Project\Appl\shared\zBrs_ArmCommon; DAV_Project\Appl\shared\zBrs_AsrEmbeddedRunTimeSystemCfg5; DAV_Project\Appl\shared\zBrs_S32Arm
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CPU_S32K148; BRS_DERIVATIVE_S32K144; BASIC_RUNTIME_SYSTEM_TYPE_MSR4
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: E:\S32K144_Start_new_IAR\Appl\S32K148Asr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group BSW/BswM
    IAR_Project/Src/BSW/BswM/: BswM.c
  group BSW/Det
    IAR_Project/Src/BSW/Det/: Det.c
  group BSW/EcuM
    IAR_Project/Src/BSW/EcuM/: EcuM.c
  group BSW/Os
    IAR_Project/Src/BSW/Os/: Os_AccessCheck.c Os_Alarm.c Os_Application.c Os_Barrier.c Os_Bit.c Os_BitArray.c Os_Core.c Os_Counter.c Os_Deque.c Os_Error.c Os_Event.c Os_Fifo.c Os_Fifo08.c Os_Fifo16.c Os_Fifo32.c Os_FifoRef.c Os_Hal_Compiler_Arm.c Os_Hal_Compiler_Iar.c Os_Hal_Compiler_TiInt.asm Os_Hal_Context_v7m.c Os_Hal_ContextAsm.asm Os_Hal_Core.c Os_Hal_Entry.c Os_Hook.c Os_Interrupt.c Os_Ioc.c Os_Isr.c Os_Job.c Os_Lock.c Os_MemoryProtection.c Os_Peripheral.c Os_PriorityQueue.c Os_Resource.c Os_Scheduler.c Os_ScheduleTable.c Os_ServiceFunction.c Os_Spinlock.c Os_Stack.c Os_Task.c Os_Thread.c Os_Timer.c Os_TimingProtection.c Os_Trace.c Os_Trap.c Os_XSignal.c
  group BSW/VStdLib
    IAR_Project/Src/BSW/VStdLib/: vstdlib.c
  group GenCode
    DAV_Project/Appl/GenData/: BswM_Lcfg.c BswM_PBcfg.c Det_Cfg.c EcuM_Cfg.c EcuM_Init_Cfg.c EcuM_Init_PBcfg.c EcuM_PBcfg.c Os_AccessCheck_Lcfg.c Os_Alarm_Lcfg.c Os_Application_Lcfg.c Os_Barrier_Lcfg.c Os_Core_Lcfg.c Os_Counter_Lcfg.c Os_Error_Lcfg.c Os_Hal_Context_Lcfg.c Os_Hal_Core_Lcfg.c Os_Hal_Entry_Lcfg.c Os_Hal_EntryAsm_Lcfg.asm Os_Hal_Interrupt_Lcfg.c Os_Hal_Kernel_Lcfg.c Os_Hal_MemoryProtection_Lcfg.c Os_Hal_Timer_Lcfg.c Os_Hook_Lcfg.c Os_Ioc_Lcfg.c Os_Isr_Lcfg.c Os_MemoryProtection_Lcfg.c Os_Peripheral_Lcfg.c Os_Resource_Lcfg.c Os_Scheduler_Lcfg.c Os_ScheduleTable_Lcfg.c Os_ServiceFunction_Lcfg.c Os_Spinlock_Lcfg.c Os_Stack_Lcfg.c Os_Task_Lcfg.c Os_TimingProtection_Lcfg.c Os_Trace_Lcfg.c Os_XSignal_Lcfg.c Rte.c
    DAV_Project/Appl/GenData/src/: Dio_Cfg.c Mcu_Cfg.c Mcu_PBcfg.c Port_Cfg.c Port_PBcfg.c
  group GenCode/Source
    DAV_Project/Appl/Source/: BswM_Callout_Stubs.c EcuM_Callout_Stubs.c Os_Callout_Stubs.c
  group Mcal/Dio
    IAR_Project/Src/MCAL/Dio_TS_T40D2M10I1R0/src/: Dio.c Dio_Gpio.c
  group Mcal/Mcu
    IAR_Project/Src/MCAL/Mcu_TS_T40D2M10I1R0/src/: Mcu.c Mcu_CMU.c Mcu_CMU_Irq.c Mcu_CortexM4.c Mcu_IPW.c Mcu_IPW_Irq.c Mcu_PCC.c Mcu_PMC.c Mcu_PMC_Irq.c Mcu_RCM.c Mcu_SCG.c Mcu_SIM.c Mcu_SMC.c
  group Mcal/Port
    IAR_Project/Src/MCAL/Port_TS_T40D2M10I1R0/src/: Port.c Port_Ipw.c Port_Port_Ci.c
  group StartUp
    IAR_Project/Src/Device/: startup.c startup_S32K148.s system_S32K148.c
